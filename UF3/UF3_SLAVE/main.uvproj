# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7323 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\h
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c key.c push.c tim1.c
