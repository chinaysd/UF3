# Keil uVision project UF3.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8370 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x7F) CLOCK(24000000)
  output: UF3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\H;.\lib
  group Source Group 1
    ./: STARTUP.A51
    ./C/: main.c system.c tim1.c test_led.c uart1.c
    ./lib/: S_TouchKeyCFG.C SC92F8X7X_HighReliability_Lib_T1_V0.0.1.LIB
